# IAR project LoRaMac_AT-Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C8 ST STM32L151C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L151xB; USE_HAL_DRIVER; REGION_CN470; USE_DEBUGGER
  ICCARM.CCIncludePath2: src\apps; src\apps\at_parser; src\boards; src\boards\CNICG-Module; src\boards\CNICG-Module\cmsis; src\boards\CNICG-Module\usb\cdc\inc; src\boards\CNICG-Module\usb\dfu\inc; src\boards\mcu\stm32; src\boards\mcu\stm32\cmsis; src\boards\mcu\stm32\STM32_USB_Device_Library\Class\CDC\Inc; src\boards\mcu\stm32\STM32_USB_Device_Library\Class\DFU\Inc; src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc; src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc\Legacy; src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc; src\mac; src\mac\region; src\radio; src\radio\sx126x; src\radio\sx1272; src\radio\sx1276; src\system; src\system\crypto; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LoRaMac_AT-Module.srec
  ILINK.IlinkOutputFile: LoRaMac_AT-Module.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    src/apps/: callback_handler.c command_parse.c eeprom_internal.c main.c
  group apps/at_parser
    src/apps/at_parser/: at_parser.c
  group boards/CNICG-Module
    src/boards/CNICG-Module/: board.c delay-board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c uart-usb-board.c
  group boards/CNICG-Module/cmsis
    src/boards/CNICG-Module/cmsis/: system_stm32l1xx.c
  group boards/CNICG-Module/cmsis/arm-std
    src/boards/CNICG-Module/cmsis/arm-std/: startup_stm32l1xx_md.s
  group boards/CNICG-Module/usb/cdc/src
    src/boards/CNICG-Module/usb/cdc/src/: usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group boards/mcu
    src/boards/mcu/: utilities.c
  group boards/mcu/stm32
    src/boards/mcu/stm32/: sysIrqHandlers.c
  group boards/mcu/stm32/STM32_USB_Device_Library/Class/CDC/Src
    src/boards/mcu/stm32/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group boards/mcu/stm32/STM32_USB_Device_Library/Core/Inc
    src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group boards/mcu/stm32/STM32_USB_Device_Library/Core/Src
    src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group boards/mcu/stm32/STM32L1xx_HAL_Driver/Src
    src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group mac
    src/mac/: LoRaMac.c LoRaMac.h LoRaMacCrypto.c
  group mac/region
    src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group radio/sx1276
    src/radio/sx1276/: sx1276.c
  group system
    src/system/: delay.c fifo.c gpio.c timer.c uart.c
  group system/crypto
    src/system/crypto/: aes.c cmac.c
